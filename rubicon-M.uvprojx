# Keil uVision project rubicon-M.uvprojx, settings and files
target DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Rubicon
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\source\user;.\source\system;..\FreeRTOS-Kernel\include;..\FreeRTOS-Kernel;..\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group system
    ./source/system/: startup_stm32f2xx.s system_stm32f2xx.c stm32f2xx.h
  group user
    ./source/user/: FreeRTOSConfig.h main.c mcu_config.c global.c user_tasks.c serial.c text.h rubicon_777.h rubicon_777.c
  group lib
    ./source/: RTOS.lib
target LIB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: Rubicon (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
